## drivers/misc/cdfingerfp/Kconfig
```kconfig
config CDFINGER_FINGERPRINT
	tristate "generic cdfinger fingerprint driver"
	default n
	help
	add support for cdfinger fingerprint driver.
```
